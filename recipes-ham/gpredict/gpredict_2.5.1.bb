require gpredict.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=892f569a555ba9c07a568a7c0c4fa63a"

SRC_URI[md5sum] = "c6acc86f9a0bf3eb8673557775e13604"
SRC_URI[sha256sum] = "c26ff5f9bfe9468bd48426dac4782f860c208960b0551feba3e38e364fbcd797"

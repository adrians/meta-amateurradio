SRC_URI = "git://github.com/pmem/ndctl.git;branch=main;protocol=https"

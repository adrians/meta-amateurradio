PACKAGECONFIG:append = " sql-sqlite"
